options:
  parameters:
    author: ''
    catch_exceptions: 'True'
    category: '[GRC Hier Blocks]'
    cmake_opt: ''
    comment: ''
    copyright: ''
    description: ''
    gen_cmake: 'On'
    gen_linking: dynamic
    generate_options: qt_gui
    hier_block_src_path: '.:'
    id: PROMEDIOS DE TIEMPO
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    qt_qss_theme: ''
    realtime_scheduling: ''
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: prompt
    sizing_mode: fixed
    thread_safe_setters: ''
    title: Promedios de Tiempo
    window_size: (1000,1000)
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [8, 8]
    rotation: 0
    state: enabled

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: ''
    value: '32000'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [200, 12]
    rotation: 0
    state: enabled
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved,\
      \ GRC will instantiate the first class it finds\nto get ports and parameters\
      \ of your block. The arguments to __init__  will\nbe the parameters. All of\
      \ them are required to have default values!\n\"\"\"\n\nimport numpy as np\n\
      from gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes\
      \ are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block\
      \ example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):\
      \  # only default arguments here\n        \"\"\"arguments to this function show\
      \ up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n         \
      \   self,\n            name= 'Promedios de tiempo',   # will show up in GRC\n\
      \            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n  \
      \      )\n        # if an attribute with the same name as a parameter is found,\n\
      \        # a callback is registered (properties work, too).\n        self.acum_anterior\
      \ = 0\n        self.Ntotales = 0\n        self.acum_anterior1 = 0\n        self.acum_anterior2\
      \ = 0\n\n\n    def work(self, input_items, output_items):\n        \"\"\"example:\
      \ multiply with constant\"\"\"\n        x = input_items[0] \n        y0 = output_items[0]\n\
      \        y1 = output_items[1] \n        y2 = output_items[2] \n        y3 =\
      \ output_items[3] \n        y4 = output_items[4]\n\n        #Calculo del promedio\n\
      \        N= len(x)9\n        self.Ntotales = self.Ntotales + N\n        acumulado\
      \ = self.acum_anterior + np.cumsum(x)\n        self.acum_anterior = acumulado\
      \ [N-1]\n        y0[:]= acumulado/self.Ntotales\n        return len(output_items[0])\n\
      \n        #Calculo de la media cuadratica\n        x2 = np.multiply(x,x)\n \
      \       acumulado1=self.acum_anterior1 + np.cumsum(x2)\n        self.acum_anerior1\
      \ = acumulado [N-1]\n        y1[:]= acumulado1/self.Ntotales\n\n        #calculoRMS\n\
      \        y2[:]=np.sqrt(y1)\n\n        #CALCULO POTENCIA PROMEDIO\n        y3[:]\
      \ = np.multiply (y2,y2)\n        \n        #CALCULO DE LA DESVIACION ESTANDAR\n\
      \        x3 = np.multiply(x-y0,x-y0)\n        acumulado2 = self.acum_anterior2\
      \ + np.cumsum(x3)\n        self.acum_anterior2 = acumulado2[N-1]\n        y4[:]\
      \ = np.sqrt(acumulado2/self.Ntotales)\n\n        return len(x)\n\n\n\n\n"
    affinity: ''
    alias: ''
    comment: ''
    example_param: '1.0'
    maxoutbuf: '0'
    minoutbuf: '0'
  states:
    _io_cache: ('Embedded Python Block', 'blk', [('example_param', '1.0')], [('0',
      'complex', 1)], [('0', 'complex', 1)], 'Embedded Python Block example - a simple
      multiply const', ['example_param'])
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [536, 240.0]
    rotation: 0
    state: enabled
connections: []

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
